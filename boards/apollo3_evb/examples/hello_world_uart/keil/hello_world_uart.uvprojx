# Keil uVision project hello_world_uart.uvprojx, settings and files
target hello_world_uart (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: hello_world_uart
  AfterMake: fromelf --bin --output bin\hello_world_uart.bin bin\hello_world_uart.axf
  AfterMake: fromelf -cedrst --output bin\hello_world_uart.txt bin\hello_world_uart.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil SX128X RP2_101 REGION_WW2G4 WW2G4_SINGLE_DATARATE
  c include: ../../../../../devices;../../../../../mcu/apollo3;../../../../../CMSIS/ARM/Include;../../../../../CMSIS/AmbiqMicro/Include;../../../../../utils;../../../bsp;../src;../../../../..;..\..\..\..\..\mcu\apollo3;..\smtc_modem_core\radio_drivers\sx128x_driver\src;..\smtc_modem_core\smtc_ral\src;..\smtc_modem_core\smtc_ral\src;..\radio_hal;..\smtc_modem_api;..\smtc_modem_hal;..\smtc_modem_core\radio_drivers\sx128x_driver\src;..\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\smtc_modem_core;..\smtc_modem_core\modem_config;..\smtc_modem_core\modem_core;..\smtc_modem_core\modem_supervisor;..\smtc_modem_core\device_management;..\smtc_modem_core\modem_services;..\smtc_modem_core\lorawan_api;..\smtc_modem_core\smtc_modem_services\headers;..\smtc_modem_core\smtc_modem_services\src;..\smtc_modem_core\smtc_modem_services\src\stream;..\smtc_modem_core\smtc_modem_services\src\file_upload;..\smtc_modem_core\smtc_modem_services\src\alc_sync;..\smtc_modem_core\smtc_modem_services;..\smtc_modem_core\smtc_ral\src;..\smtc_modem_core\smtc_ralf\src;..\smtc_modem_core\lr1mac;..\smtc_modem_core\lr1mac\src;..\smtc_modem_core\lr1mac\src\services;..\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\smtc_modem_core\radio_planner\src;..\smtc_modem_core\smtc_modem_crypto;..\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\smtc_modem_core\lorawan_api;..\smtc_modem_hal;..\smtc_modem_core\lr1mac\src\smtc_real\src
  asm include: ..\src
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\hello_world_uart.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: main.c smtc_hal_spi.c smtc_hal_gpio.c smtc_hal_lp_timer.c smtc_hal_rtc.c smtc_hal_trace.c smtc_hal_rng.c smtc_hal_flash.c smtc_hal_mcu.c tx_rx_test.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
  group radio_hal
    ../radio_hal/: ral_sx128x_bsp.c sx128x_hal.c
  group smtc_modem_hal
    ../smtc_modem_hal/: smtc_modem_hal.c
  group smtc_modem_core
    ../smtc_modem_core/lorawan_api/: lorawan_api.c
    ../smtc_modem_core/smtc_ralf/src/: ralf_sx128x.c
    ../smtc_modem_core/radio_drivers/sx128x_driver/src/: sx128x.c
    ../smtc_modem_core/device_management/: dm_downlink.c modem_context.c
    ../smtc_modem_core/lr1mac/src/smtc_real/src/: region_ww2g4.c smtc_real.c region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c
    ../smtc_modem_core/smtc_modem_crypto/soft_secure_element/: cmac.c soft_se.c aes.c
    ../smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_test.c
    ../smtc_modem_core/modem_services/: modem_utilities.c smtc_modem_services_hal.c lorawan_certification.c fifo_ctrl.c smtc_clock_sync.c
    ../smtc_modem_core/modem_supervisor/: modem_supervisor.c
    ../smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_utilities.c lr1mac_core.c
    ../smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_multicast.c
    ../smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    ../smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_ping_slot.c smtc_beacon_sniff.c smtc_d2d.c
    ../smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    ../smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
    ../smtc_modem_core/smtc_ral/src/: ral_sx128x.c
    ../smtc_modem_core/modem_services/fragmentation/: frag_decoder.c fragmented_data_block.c patch_upd.c
    ../smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../smtc_modem_core/smtc_modem_services/src/almanac_update/: almanac_update.c
    ../smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../smtc_modem_core/smtc_modem_services/src/stream/: stream.c rose.c
